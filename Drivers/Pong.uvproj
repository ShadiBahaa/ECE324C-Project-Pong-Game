# Keil uVision project Pong.uvproj, settings and files
target HelloLaunchPad (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: HelloLaunchPad
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s
    ./APP/: main.c
    ./HAL/N5110/: N5110_prg.c
    ./MCAL/GPIO/: GPIO.c GPIO_Cfg.c
    ./MCAL/GPTM/: GPTM_Config.c GPTM_Source.c
    ./MCAL/NVIC/: NVIC_prg.c
    ./MCAL/SSI/: SSI_prg.c
    ./MCAL/UART/: UART_Config.c UART_Source.c
    ./MCAL/ADC/: ADC.c
